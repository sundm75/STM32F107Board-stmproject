# IAR project project.ewp, settings and files
configuration STM32F107Board (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: ..\src; ..\drivers; ..\emWin_Config; ..\emWin_Demo; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STemWinLibrary522\inc; ..\..\..\..\Libraries\STemWinLibrary522\Config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group drivers
    ../drivers/: lcd.c timer5.c touch_spi.c
  group emWin_Config
    ../emWin_Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf.c TOUCH_Sample.c
  group emWin_demo
    ../emWin_Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group EWARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group STemWin_V522/Config
    ../../../../Libraries/STemWinLibrary522/OS/: GUI_X.c
  group STemWin_V522/Lib
    ../../../../Libraries/STemWinLibrary522/Lib/: STemWin522_CM3_IAR.a
  group STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../src/: calculator.c main.c
