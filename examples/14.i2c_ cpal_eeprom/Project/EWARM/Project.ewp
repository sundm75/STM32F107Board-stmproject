# IAR project Project.ewp, settings and files
configuration STM32F107Board (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\drivers\; ..\STM32_CPAL_Driver\inc; ..\STM32_CPAL_Driver; ..\STM32_CPAL_Driver\devices\stm32f10x; ..\src\; ..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Cpal_I2C
    ../STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
    ../STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
    ../STM32_CPAL_Driver/: cpal_usercallback.c stm32_eval_i2c_ee_cpal.c
  group Doc
    ./: readme.txt
  group drivers
    ../drivers/: delay.c key.c led.c usart.c
  group EWARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../src/: main.c stm32f10x_it.c
